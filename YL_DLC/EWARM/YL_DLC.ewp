# IAR project YL_DLC.ewp, settings and files
configuration YL_DLC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/Scale; ../Src/Scale/Filter; ../Src/commsrc; ../Src/util; ../ADC_Driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: YL_DLC.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../ADC_Driver/: ADS1230.c ADS1230.h
    ../Src/: CmdProcess.c dma.c freertos.c gpio.c i2c.c main.c ModbusRTUSlave.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c usart.c
  group Application/User/Comm
    ../Src/commsrc/: comm.c comm.h SetupParameterTable.h UserParam.c UserParam.h
  group Application/User/RB/util
    ../Src/util/: RB_Format.c RB_String.c
  group Application/User/Scale
    ../Src/Scale/: Cal.c Motion.c Scale.c Tare.c Unit.c Zero.c
  group Application/User/Scale/Filter
    ../Src/Scale/Filter/: Filter.c filter.h J_FILTER.C MyFilter.c NotchIIRFilter.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
